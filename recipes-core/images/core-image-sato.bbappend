


EXTRA_IMAGE_FEATURES:append = " dev-pkgs"

IMAGE_INSTALL:append = " app-qfom app-qt lshw ninja minicom htop nano tree packagegroup-core-buildessential cmake"
IMAGE_INSTALL:append = " qtbase qtdeclarative qtquickcontrols qtbase-tools qtbase-plugins"
